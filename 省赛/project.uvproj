# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: project
  c flags: Optimize=8 SizeSpeed=1
  c include: .\hardware
  group Source Group 1
    ./: STARTUP.A51 main.c
  group hardware
    ./hardware/: led.c led.h seg.c seg.h key.c key.h
